# Keil uVision project ca51m151.uvproj, settings and files
target CA51F (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: ca51m151 +hex
  c flags: Optimize=9
  c include: .\RTOS
  link misc: REMOVEUNUSED
  group Source Files
    ./source/: main.c delay.c system_clock.c uart.c interrupt.c
  group Lib
    ./lib/: STARTUP.A51
  group RTOS
    ./RTOS/: rtos.c
